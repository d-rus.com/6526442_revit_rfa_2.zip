Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Compound-Units_DURAVIT_DE4948-D-Neo-Vanity-unit-wall-mounted.ifc
Time: 2021-04-15T10:47:45
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, DE4948 D-Neo Vanity unit wall-mounted
ePset_BIMobjectScript - Color: M18 White Matt; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DE4948 D-Neo Vanity unit wall-mounted; SKU (BO_prodsku): d-neo-vanity-unit-wall-mounted-de4948; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): D-Neo; ProductGroup (BO_prodgroup): Vanity units; EditionNumber (BO_edinum): 1; Width (BO_width): 1000; Height (BO_height): 459; Depth (BO_depth): 550; Weight (BO_weight): 27; QR (BO_boqrurl): http://bimobject.com/duravit/product/d-neo-vanity-unit-wall-mounted-de4948; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/d-neo-vanity-unit-wall-mounted-de4948; ProductUrl (BO_producturl): https://pro.duravit.com/p/DE4948; InstallationInstructions (BO_montins): https://pro.duravit.com/p/DE4948; ProductCertification (BO_prodcert): https://pro.duravit.com/p/DE4948; GtinCode (BO_gtin): 4063382109163; MaterialMain (BO_mainmat): Wood; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Compound Units; BimObjectCategoryCode (BO_bocat_code): sanitary-compound-units; IfcClassification (BO_ifcclas): Furnishing Element; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8241; Uniclass14Description (BO_uniclass_1_4_desc): Bathroom cabinets; Uniclass20Code (BO_uniclass_2_0_code): PR-35-75-08; Uniclass20Description (BO_uniclass_2_0_desc): Bathroom Cabinets; Uniclass2015Code (BO_uniclass2015_code): Pr_40_30_78_05; Uniclass2015Description (BO_uniclass2015_desc): Bathroom furniture; NBSReference (BO_nbs_ref): 35-75-08; NBSReferenceDescription (BO_nbs_desc): Bathroom Cabinets; OmniClassCode (BO_omniclass_code): 23-19 31 17 11; OmniClassDescription (BO_omniclass_name): Bathroom Units; MasterFormat2014Code (BO_masterformat2014_code): 12 50 00; MasterFormat2014Description (BO_masterformat2014_name): Furniture; UniFormat2Code (BO_uniformat2_code): E2010; UniFormat2Description (BO_uniformat2_name): Fixed Furnishings; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
